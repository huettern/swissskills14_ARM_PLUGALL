# Keil uVision project plugall.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F372R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: plugall +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_FULL_ASSERT  USE_STDPERIPH_DRIVER
  c include: .\system;.\std_periph_lib;.\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group system
    ./system/: startup_stm32f37x.s stm32f37x_conf.h system_stm32f37x.c
  group user
    ./user/: main.c plugall.c plugall.h DAC.c DAC.h SPI.c SPI.h I2C.c I2C.h ADC.c ADC.h INT.c INT.h shell.c shell.h LCD.c LCD.h delay.c delay.h
  group std_periph_lib
    ./std_periph_lib/: stm32f37x_adc.c stm32f37x_dbgmcu.c stm32f37x_exti.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c stm32f37x_dma.c
